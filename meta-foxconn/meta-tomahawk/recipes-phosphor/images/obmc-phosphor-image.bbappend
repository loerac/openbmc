OBMC_IMAGE_EXTRA_INSTALL_append_tomahawk = " mboxd liberation-fonts uart-render-controller"
IMAGE_INSTALL += "foxconn-oem-ipmi \
                  ipmitool \
                 "
